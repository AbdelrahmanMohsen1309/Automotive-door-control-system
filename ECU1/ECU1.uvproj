# Keil uVision project ECU1.uvproj, settings and files
target ECU1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: ECU1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Libraries;.\OS\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Device
    ./: Startup.s
  group Application
    ./Application/: InputControlUnit.c
  group Service
    ./Services/: CommMng.c SensorMng.c
  group HAL
    ./HAL/: DoorSensor.c LightSwitch.c SpeedSensor.c
  group MCAL
    ./MCAL/: CAN.c GPIO.c
  group OS
    ./OS/: croutine.c event_groups.c heap_2.c list.c port.c portASM.s queue.c stream_buffer.c tasks.c timers.c
  group Configurations
    ./Libraries/: CONFIGURATIONS.h FreeRTOSConfig.h
