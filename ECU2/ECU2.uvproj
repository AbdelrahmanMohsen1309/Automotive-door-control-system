# Keil uVision project ECU2.uvproj, settings and files
target ECU2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: ECU2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Libraries;.\OS\include;.\OS\portable\RVDS\ARM7_LPC21xx
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Device
    ./: Startup.s
  group Application
    ./Application/: OutputControlUnit.c
  group MCAL
    ./MCAL/: CAN.c GPIO.c Timer.c
  group HAL
    ./HAL/: Buzzer.c Lights.c
  group OS
    ./OS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c heap_2.c
    ./OS/portable/RVDS/ARM7_LPC21xx/: portASM.s port.c
  group Configurations
    ./Libraries/: CONFIGURATIONS.h FreeRTOSConfig.h
  group Service
    ./Services/: CommMng.c ExtDvsMng.c
